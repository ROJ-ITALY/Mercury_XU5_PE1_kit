# Change SRCREV to fix bug in ImageBuilder

SRCREV = "7760210b3c0e4ac29b7a7e5e2daba86f34ca79c2"
