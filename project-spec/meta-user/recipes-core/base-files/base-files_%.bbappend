# Customize /etc/profile

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
